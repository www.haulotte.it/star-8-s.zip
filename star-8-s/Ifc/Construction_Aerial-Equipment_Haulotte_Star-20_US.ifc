Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:31:26
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:31:26 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{B2F1153E-E052-4799-B0EB-B152CAA25B7F}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:31:15 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:31:15 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:31:15 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Star 22J, Construction_Aerial-Equipment_Haulotte_Star-22J_US:Star 22J:4036216
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Black, Metal - Haulotte - Red, Working_Area, Metal - Haulotte - Yellow, Metal - Haulotte - Grey
Type - Autre(Type) - Catégorie: Equipement spécialisé; Hydraulic System Capacity: 9; Machine Weight: 2605 kg - (5743.04 lb); Nom de la famille: Construction_Aerial-Equipment_Haulotte_Star-22J_US
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Vertical Mast; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Star 22J; Nom du type: Star 22J; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/star-8; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte-usa.com/
Type - Données(Type) - Batteries: 24 V - 250 Ah; Driveable at Full Height up to: 8.75 m - (344.49 in); Drive Speed: 5 - 0.6 km/h - (3.11- 0.37mph); Gradeability: 25%; Ground Clearance: 0.06 m - (2.36 in); Ground Clearance - Pothole Guards Deployed: 0.01 m - (0.39 in); Height - Stowed: 1.95 m - (78.54 in); Horizontal Outreach: 3.06 m - (120.67 in); Jib Length: 2.25 / 0.68 m - (88.58 /26.77 in); Length: 2.7 m - (106.30 in); Length Extension: 0.4 m - (15.75 in); Lift Capacity – Inside: 200 kg - (440.92 in); Max Ground Pressure of Wheel on Paved Ground: 13.93 daN/cm2; Overall Width: 0.79 m - (31.10 in); Platform Height: 6.7 m - (265.75 in); Platform Length: 1.37 m - (54.13 in); Platform Length – Extended: 1.8 m - (69.88 in); Platform Size: 0.78x0.98 m - (30.71x38.58 in); Platform Width: 0.79 m - (31.10 in); Tailswing: 0; Tilt: 3°; Tires: 406 x 100 mm - (15.98 3.93 in); Turning Radius - Inside: 00.45 m - (17.64 in); Turning Radius - Outside: 1.88 m - (74.02 in); Up and Over Clearance: 6.2 m/ 244.09 in; Wheelbase: 1.2 m - (47.24 in); Width: 1 m - (39.37 in); Working Height: 8.7 m - (344.49 in)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Star 22J
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - a: 225 deg; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Star-22J_US: Star 22J; Famille et type: Construction_Aerial-Equipment_Haulotte_Star-22J_US: Star 22J; ID du type: Construction_Aerial-Equipment_Haulotte_Star-22J_US: Star 22J; Tr cntrl: 0 deg; Type: Construction_Aerial-Equipment_Haulotte_Star-22J_US: Star 22J
Construction - Platform Height: 6.7 m; Reach Diagram: yes; Turnable Rotation: 0 deg; Turning Radius: yes; Vertical Jib Rotation Angle: 70 deg; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 37.7774 m2; Volume: 11.5104 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
