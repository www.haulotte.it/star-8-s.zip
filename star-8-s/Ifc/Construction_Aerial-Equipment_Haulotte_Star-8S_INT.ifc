Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:34:56
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:34:56 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{69C9C58C-6A36-443F-811C-3553F52F6E73}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:34:51 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:34:51 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:34:51 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: Star 8S, Construction_Aerial-Equipment_Haulotte_Star-8S_INT:Star 8S:4036207
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Working_Area, Metal - Haulotte - Black, Red, Metal - Haulotte - Yellow, Metal - Haulotte - Grey, Metal - Haulotte - Light Grey
Type - Autre(Type) - Catégorie: Equipement spécialisé; Hydraulic System Capacity: 9; Machine Weight: 1150 kg - (2535.32 lb); Nom de la famille: Construction_Aerial-Equipment_Haulotte_Star-8S_INT
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Vertical Mast; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: Star 8S; Nom du type: Star 8S; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/star-8-s; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.co.uk
Type - Données(Type) - Batteries: 4 x 12 V - 180 Ah; Driveable at Full Height up to: 5.95 m - (234.25 in); Drive Speed: 4.5 - 0.5km/h - (2.8 - 0.31 mph); Gradeability: 25%; Ground Clearance: 0.06 m - (2.36 in); Ground Clearance - Pothole Guards Deployed: 0.016 m - (0.63 in); Height - Stowed: 1.98 m - (77.95 in); Length: 1.40 m - (55.12 in); Length Extension: 0.4 m - (15.75 in); Lift Capacity – Inside: 200 kg - (440.92 in); Max Ground Pressure of Wheel on Paved Ground: 14.21 daN/cm2; Overall Width: 0.79 m - (31.10 in); Platform Height: 5.95 m - (234.25 in); Platform Length: 1.37 m - (54.13 in); Platform Length – Extended: 1.8 m - (69.88 in); Platform Size: 0.77x1.38 m - (30.31x54.13 in); Platform Width: 0.79 m - (31.10 in); Tilt: 1,5° / 3°; Tires: 0.318x0.108 mm / 12.52x4.25 in; Turning Radius - Inside: 0.35 m - (13.75 in); Turning Radius - Outside: 1.58 m - (62.01 in); Wheelbase: 1.07 m - (42.32 in); Width: 0.79 m - (31.10 in); Working Height: 7.95 m - (312.99)
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: Star 8S
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A2: yes; A2 lngt: 4.49 m; A2 lngt cntrl: 4.49 m; A3: yes; A3 lngt: 3.16 m; A3 lngt cntl: 3.16 m; A4: yes; A4 lngt: 1.83 m; A4 lngt cntrl: 1.83 m; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_Star-8S_INT: Star 8S; Famille et type: Construction_Aerial-Equipment_Haulotte_Star-8S_INT: Star 8S; H CTRL: 5.95 m; ID du type: Construction_Aerial-Equipment_Haulotte_Star-8S_INT: Star 8S; Type: Construction_Aerial-Equipment_Haulotte_Star-8S_INT: Star 8S
Construction - Extension Desk Length: 0.4 m; Platform Height: 5.95 m; Reach Diagram: yes; Turning Radius: yes; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 37.2956 m2; Volume: 11.0946 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
